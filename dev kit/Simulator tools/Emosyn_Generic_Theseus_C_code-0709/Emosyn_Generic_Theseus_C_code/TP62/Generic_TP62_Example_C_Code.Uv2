### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Theseus Platinum 62 Example C Code), 0x0000 // Tools: 'MCS-51'

Group (Theseus Platinum 62 Specific)
Group (Common TP40 TP62)
Group (Common Theseus Platinum Family)
Group (Common Theseus Family)
Group (Firmware Calls)

File 1,1,<.\TP62_Get_OS_Version.c><TP62_Get_OS_Version.c> 0x0 
File 1,1,<.\TP62_ISR.c><TP62_ISR.c> 0x0 
File 1,1,<.\TP62_MassEraseEE_Bootloader_Safe.c><TP62_MassEraseEE_Bootloader_Safe.c> 0x0 
File 1,1,<.\TP62_Send_ATR.c><TP62_Send_ATR.c> 0x0 
File 1,2,<.\TP62_STARTUP.A51><TP62_STARTUP.A51> 0x0 
File 1,4,<.\TP62_API_JumpTable.LIB><TP62_API_JumpTable.LIB> 0x42F89946 
File 2,2,<..\Common_TP40_TP62\TP40_TP62_Erase_Back_To_Factory_State.A51><TP40_TP62_Erase_Back_To_Factory_State.A51> 0x0 
File 2,1,<..\Common_TP40_TP62\TP40_TP62_Memory_Write.c><TP40_TP62_Memory_Write.c> 0x0 
File 3,1,<..\Common_Platinum\Chip_Init.c><Chip_Init.c> 0x0 
File 4,1,<..\Common\Global_Vars.c><Global_Vars.c> 0x0 
File 4,1,<..\Common\IO.c><IO.c> 0x0 
File 4,1,<..\Common\CRC16_Normal.c><CRC16_Normal.c> 0x0 
File 4,1,<..\Common\Set_Idle_Mode.c><Set_Idle_Mode.c> 0x0 
File 4,1,<..\Common\ISO_Select_Speed.c><ISO_Select_Speed.c> 0x0 
File 4,1,<..\Common\Main.c><Main.c> 0x0 
File 4,1,<..\Common\SHA-1.c><SHA-1.c> 0x0 
File 4,1,<..\Common\Change_ISO_Speed.c><Change_ISO_Speed.c> 0x0 
File 4,1,<..\Common\Get_Security_Status.c><Get_Security_Status.c> 0x0 
File 4,1,<..\Common\Set_Security_Status.c><Set_Security_Status.c> 0x0 
File 4,1,<..\Common\Write_UCM_Bytes_Flash_Mode_From_IRAM_Buffer.c><Write_UCM_Bytes_Flash_Mode_From_IRAM_Buffer.c> 0x0 
File 4,1,<..\Common\Write_EE_Bytes_Flash_Mode_From_IRAM_Buffer.c><Write_EE_Bytes_Flash_Mode_From_IRAM_Buffer.c> 0x0 
File 4,1,<..\Common\Code_Memory_Dump.c><Code_Memory_Dump.c> 0x0 
File 4,1,<..\Common\XDATA_Memory_Dump.c><XDATA_Memory_Dump.c> 0x0 
File 4,1,<..\Common\IDATA_Memory_Dump.c><IDATA_Memory_Dump.c> 0x0 
File 4,1,<..\Common\Write_To_RAM.c><Write_To_RAM.c> 0x0 
File 4,1,<..\Common\Get_Response.c><Get_Response.c> 0x0 
File 4,1,<..\Common\Conv_Two_Bytes_To_Int.c><Conv_Two_Bytes_To_Int.c> 0x0 
File 5,1,<..\Common\Erase_EE_64_Bytes.c><Erase_EE_64_Bytes.c> 0x0 
File 5,1,<..\Common\Mass_Erase_EE.c><Mass_Erase_EE.c> 0x0 
File 5,1,<..\Common\Get_Clock_Source.c><Get_Clock_Source.c> 0x0 
File 5,1,<..\Common\Get_Clock_Control.c><Get_Clock_Control.c> 0x0 
File 5,1,<..\Common\Set_Execute_Only_Status.c><Set_Execute_Only_Status.c> 0x0 
File 5,1,<..\Common\Set_Protection_Status.c><Set_Protection_Status.c> 0x0 
File 5,1,<..\Common\Set_Security_Action.c><Set_Security_Action.c> 0x0 
File 5,1,<..\Common\Set_Security_Mask.c><Set_Security_Mask.c> 0x0 
File 5,1,<..\Common\Write_Byte_EE_Flash_Mode.c><Write_Byte_EE_Flash_Mode.c> 0x0 
File 5,1,<..\Common\Write_Byte_UCM_Flash_Mode.c><Write_Byte_UCM_Flash_Mode.c> 0x0 
File 5,1,<..\Common\Erase_24K_Block.c><Erase_24K_Block.c> 0x0 
File 5,1,<..\Common\Erase_EE_8_Bytes.c><Erase_EE_8_Bytes.c> 0x0 
File 5,1,<..\Common\Get_Firmware_Version.c><Get_Firmware_Version.c> 0x0 
File 5,1,<..\Common\Erase_UCM_Page.c><Erase_UCM_Page.c> 0x0 
File 5,1,<..\Common\Get_Chip_ID.c><Get_Chip_ID.c> 0x0 
File 5,1,<..\Common\Set_Interrupt_Enable.c><Set_Interrupt_Enable.c> 0x0 
File 5,1,<..\Common\Get_Interrupt_Enable.c><Get_Interrupt_Enable.c> 0x0 
File 5,1,<..\Common\Set_Clock.c><Set_Clock.c> 0x0 
File 5,1,<..\Common\Erase_UCM_Configurable_Block.c><Erase_UCM_Configurable_Block.c> 0x0 
File 5,1,<..\Common\Mass_Erase_UCM.c><Mass_Erase_UCM.c> 0x0 
File 5,1,<..\Common\Get_Random_Number.c><Get_Random_Number.c> 0x0 


Options 1,0,0  // Target 'Theseus Platinum 62 Example C Code'
 Device (Theseus Platinum 62)
 Vendor (Emosyn)
 Cpu (IRAM(0-0xFF) CLOCK(60000000) MODDP2  XRAM(0-0x3FF) IROM(0-03FF))
 FlashUt ()
 StupF ()
 FlashDR ()
 Rgf (platinum62.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin (C:\Keil\C51\BIN\)
 EnvInc ()
 EnvLib ()
 EnvReg (ÿEmosyn\)
 OrgReg (ÿEmosyn\)
 TgStat=0
 OutDir (.\)
 OutName (Generic_TP62_Example_C_Code)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=0
 MG32K=1
 TGMORE=0
 RunUsr 0 0 <Cleanup.bat>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=368
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,104,0,0,0,148,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 0,0,0,0,0,0,0,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,4,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21630224
 C51VA=26624
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=68
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL (CONST (C:0x6800-C:0xF800))
 LX51CSC ()
 LX51UCS ()
 LX51COB (0X6800-0XFBFF)
 LX51XDB (0X0000-0X03FF)
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(TP51.DLL)(-p51)(S8051.DLL)()(TP51.DLL)(-p51)
  OPTDBG 1022,-1,()()()()()()()()()() (C:\Keil\Emosyn\TheseusKeil.dll)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (C:\Keil\Emosyn\TheseusKeil.dll)
 FLASH3 ("" ())
EndOpt

