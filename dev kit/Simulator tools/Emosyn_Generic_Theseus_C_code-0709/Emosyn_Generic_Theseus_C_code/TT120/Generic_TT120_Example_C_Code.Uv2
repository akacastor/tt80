### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Theseus Titanium 120 Example C Code), 0x0000 // Tools: 'MCS-51'

Group (Theseus Titanium 120 Specific)
Group (Common Theseus Titanium Family)
Group (Common Theseus Family)
Group (Firmware / FSM Calls)

File 1,1,<.\TT120_Get_OS_Version.c><TT120_Get_OS_Version.c> 0x0 
File 1,1,<.\TT120_Send_ATR.c><TT120_Send_ATR.c> 0x0 
File 1,2,<.\TT120_STARTUP.A51><TT120_STARTUP.A51> 0x0 
File 1,1,<.\TT120_ISR.c><TT120_ISR.c> 0x0 
File 1,2,<.\TT120_Mass_Erase_UCM_Leaving_Bootloader.a51><TT120_Mass_Erase_UCM_Leaving_Bootloader.a51> 0x0 
File 1,2,<.\TT120_API_JumpTable.a51><TT120_API_JumpTable.a51> 0x0 
File 2,1,<..\Common_Titanium\Chip_Init.c><Chip_Init.c> 0x0 
File 2,1,<..\Common_Titanium\Get_Interrupt_Enable.c><Get_Interrupt_Enable.c> 0x0 
File 2,1,<..\Common_Titanium\Set_Interrupt_Enable.c><Set_Interrupt_Enable.c> 0x0 
File 2,1,<..\Common_Titanium\Get_Pullup_Resistor.c><Get_Pullup_Resistor.c> 0x0 
File 2,1,<..\Common_Titanium\Set_Pullup_Resistor.c><Set_Pullup_Resistor.c> 0x0 
File 3,1,<..\Common\Global_Vars.c><Global_Vars.c> 0x0 
File 3,1,<..\Common\IO.c><IO.c> 0x0 
File 3,1,<..\Common\Main.c><Main.c> 0x0 
File 3,1,<..\Common\SHA-1.c><SHA-1.c> 0x0 
File 3,1,<..\Common\Set_Idle_Mode.c><Set_Idle_Mode.c> 0x0 
File 3,1,<..\Common\ISO_Select_Speed.c><ISO_Select_Speed.c> 0x0 
File 3,1,<..\Common\Change_ISO_Speed.c><Change_ISO_Speed.c> 0x0 
File 3,1,<..\Common\Set_Security_Status.c><Set_Security_Status.c> 0x0 
File 3,1,<..\Common\Get_Security_Status.c><Get_Security_Status.c> 0x0 
File 3,1,<..\Common\Get_Response.c><Get_Response.c> 0x0 
File 3,1,<..\Common_Titanium\Timer0_Functions.c><Timer0_Functions.c> 0x0 
File 3,1,<..\Common\Write_UCM_Bytes_From_IRAM_Buffer_Extended_Addressing.c><Write_UCM_Bytes_From_IRAM_Buffer_Extended_Addressing.c> 0x0 
File 3,1,<..\Common\Get_TCON.c><Get_TCON.c> 0x0 
File 3,1,<..\Common\CRC16_Normal.c><CRC16_Normal.c> 0x0 
File 3,1,<..\Common\CODE_Memory_Dump_Extended_Addressing.c><CODE_Memory_Dump_Extended_Addressing.c> 0x0 
File 3,1,<..\Common\XDATA_Memory_Dump_Extended_Addressing.c><XDATA_Memory_Dump_Extended_Addressing.c> 0x0 
File 3,1,<..\Common\IDATA_Memory_Dump.c><IDATA_Memory_Dump.c> 0x0 
File 3,1,<..\Common\Conv_Two_Bytes_To_Int.c><Conv_Two_Bytes_To_Int.c> 0x0 
File 3,1,<..\Common\Write_To_IRAM.c><Write_To_IRAM.c> 0x0 
File 3,1,<..\Common\Write_To_XRAM_Extended_Addressing.c><Write_To_XRAM_Extended_Addressing.c> 0x0 
File 3,2,<..\Common\Software_APIs_Extended_Addressing.a51><Software_APIs_Extended_Addressing.a51> 0x0 
File 4,1,<..\Common\Get_Chip_ID.c><Get_Chip_ID.c> 0x0 
File 4,1,<..\Common\Get_Clock_Source.c><Get_Clock_Source.c> 0x0 
File 4,1,<..\Common\Get_Diagnostic_Data.c><Get_Diagnostic_Data.c> 0x0 
File 4,1,<..\Common\Set_Security_Mask.c><Set_Security_Mask.c> 0x0 
File 4,1,<..\Common\Get_Clock_Control.c><Get_Clock_Control.c> 0x0 
File 4,1,<..\Common\Set_Security_Action.c><Set_Security_Action.c> 0x0 
File 4,1,<..\Common\Get_Firmware_Version.c><Get_Firmware_Version.c> 0x0 
File 4,1,<..\Common\Load_DPX.c><Load_DPX.c> 0x0 
File 4,1,<..\Common\Set_Clock.c><Set_Clock.c> 0x0 
File 4,1,<..\Common\Erase_256_UCM_Extended_Addressing.c><Erase_256_UCM_Extended_Addressing.c> 0x0 
File 4,1,<..\Common\Erase_512_UCM_Extended_Addressing.c><Erase_512_UCM_Extended_Addressing.c> 0x0 
File 4,1,<..\Common\Write_Byte_UCM_Extended_Addressing.c><Write_Byte_UCM_Extended_Addressing.c> 0x0 
File 4,1,<..\Common\Get_Random_Number.c><Get_Random_Number.c> 0x0 
File 4,1,<..\Common\Set_Execute_Only_Status.c><Set_Execute_Only_Status.c> 0x0 
File 4,1,<..\Common\Set_Protection_Status.c><Set_Protection_Status.c> 0x0 
File 4,1,<..\Common\Erase_UCM_Blocks__R6R7_Passing.c><Erase_UCM_Blocks__R6R7_Passing.c> 0x0 
File 4,1,<..\Common\Mass_Erase_UCM.c><Mass_Erase_UCM.c> 0x0 
File 4,2,<.\INIT.A51><INIT.A51> 0x0 


Options 1,0,0  // Target 'Theseus Titanium 120 Example C Code'
 Device (Theseus Titanium 120 ver2_0)
 Vendor (Emosyn)
 Cpu (IRAM(0-0xFF) CLOCK(40000000) MOD_CONT XRAM(0x01E800-0x1EFFF))
 FlashUt ()
 StupF ()
 FlashDR ()
 DevID ()
 Rgf ()
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin (C:\Keil\C51\BIN\)
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg (ÿEmosyn\)
 TgStat=16
 OutDir (.\)
 OutName (Generic_TT120_Example_C_Code)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=3
 DHOLD5=0
 XHOLD5=0
 T51FL=639024
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,8,0,0,0,224,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,232,1,0,0,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 0,0,0,0,0,0,0,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,232,1,0,0,8,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=17435920
 C51VA=2048
 C51MSC ()
 C51DEF (EXTENDED_ADDRESSING)
 C51UDF ()
 INCC5 ()
 AX51FL=68
 AX51MSC ()
 AX51SET (EXTENDED_ADDRESSING)
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL (CONST (C:0x800-C:0xFFFF))
 LX51CSC ()
 LX51UCS ()
 LX51COB (0X0800-0XFCFF)
 LX51XDB (0X0400-0X087F)
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)(-c390)(DP51.DLL)(-p390)(S8051.DLL)(-c390)(TP51.DLL)(-p390)
  OPTDBG 48126,-1,()()()()()()()()()() (C:\Keil\Emosyn\TheseusKeil.dll)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (C:\Keil\Emosyn\TheseusKeil.dll)
 FLASH3 ()
 FLASH4 ()
EndOpt

