### uVision2 Project, (C) Keil Software
### Do not modify !

Target (TT40 Bootloader), 0x0000 // Tools: 'MCS-51'

Group (Core Bootloader)
Group (Normal_Bootloader)
Group (Apdu_Bootloader)

File 1,2,<.\TT40_Core_Bootloader.A51><TT40_Core_Bootloader.A51> 0x0 
File 2,2,<.\TT40_Normal_Bootloader.A51><TT40_Normal_Bootloader.A51> 0x0 
File 3,2,<.\TT40_APDU_Bootloader.A51><TT40_APDU_Bootloader.A51> 0x0 
File 3,2,<.\SelectFiDi.a51><SelectFiDi.a51> 0x0 
File 3,1,<.\ATR.c><ATR.c> 0x0 
File 3,1,<.\Set_PPS.c><Set_PPS.c> 0x0 
File 3,1,<.\crc16_32bitVar.c><crc16_32bitVar.c> 0x0 
File 3,1,<.\BulkCheckum_32bits_TT40.c><BulkCheckum_32bits_TT40.c> 0x0 
File 3,1,<.\LoadKey.c><LoadKey.c> 0x0 


Options 1,0,0  // Target 'TT40 Bootloader'
 Device (Theseus Titanium 40)
 Vendor (Emosyn)
 Cpu (IRAM(0-0xFF) CLOCK(3571200) MODDP2  XRAM(0xB000-0xB1FF) IROM(0x0400-0xA3FF))
 FlashUt ()
 StupF ()
 FlashDR ()
 DevID (0)
 Rgf (Theseus_Titanium_Family.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin (C:\Keil\C51\BIN\)
 EnvInc ()
 EnvLib ()
 EnvReg (ÿEmosyn\)
 OrgReg (ÿEmosyn\)
 TgStat=16
 OutDir (.\)
 OutName (TT40_Bootloader_Full_PRODUCTION25K)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <ChangeBootloaderRecords.exe "TT40_Bootloader_Full_PRODUCTION25K.hex" Full_Bootloader.hex>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=0
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=98672
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,157,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,176,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,4,0,0,0,160,0,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,176,0,0,0,2,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21646608
 C51VA=0
 C51MSC ()
 C51DEF (PRODUCTION)
 C51UDF ()
 INCC5 ()
 AX51FL=68
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=300
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS (?PR?CORE_BOOTLOADER_SEGMENT?CORE_BOOTLOADER(C:0x9C00), ?PR?NORMAL_BOOTLOADER_SEGMENT?NORMAL_BOOTLOADER(C:0x9D00))
 LX51COB (0X9D00-0XA3FF)
 LX51XDB (0XB000-0XB1FF)
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS (?PR?CORE_BOOTLOADER_SEGMENT?CORE_BOOTLOADER(09C00h), ?PR?NORMAL_BOOTLOADER_SEGMENT?NORMAL_BOOTLOADER(09D00h))
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DSmart51.DLL)(-pTT40 -dSST_TT)(S8051.DLL)()(TP51.DLL)(-p51)
  OPTDBG 44029,-1,()()()()()()()()()() (C:\Keil\Emosyn\TheseusKeil.dll)()()()
 FLASH1 { 1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (C:\Keil\Emosyn\TheseusKeil.dll)
 FLASH3 ()
 FLASH4 ()
EndOpt

